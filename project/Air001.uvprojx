# Keil uVision project Air001.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Air001 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: AIR001_DEV
  c include: ..\Project;.\AIR001xx_HAL_Driver\Inc;.\AIR001xx_HAL_Driver\Inc\Legacy;..\gpio;..\Project
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c air001xx_hal_conf.h air001xx_it.h air001xx_it.c NRF24L01.c NRF24L01.h Delay.c I2C.c MPU6050.c usart.c usart.h air001_Core_Board.c MPU6050_TIMER.c MPU6050_TIMER.h PWM.c BMP280.c BMP280.h BMP280_I2C.c BMP280_I2C.h
  group HAL
    ./AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_cortex.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_tim.c air001xx_hal_tim_ex.c air001xx_hal_dma.c air001xx_hal_uart.c
software components: CMSIS:CORE 5.6.0, Device:Startup 0.0.1
